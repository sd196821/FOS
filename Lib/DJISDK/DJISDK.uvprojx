# Keil uVision project DJISDK.uvprojx, settings and files
target DJISDK (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DJISDK
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F407xx
  c include: .\DJI_LIB;.\RTE;.\RTE\Device\STM32F407ZGTx;.\RTE\Device\STM32F407ZGTx\STCubeGenerated;.\RTE\Device\STM32F407ZGTx\STCubeGenerated\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\RTE\Device\STM32F407ZGTx\STCubeGenerated\Drivers\CMSIS\Include;.\RTE\Device\STM32F407ZGTx\STCubeGenerated\Drivers\STM32F4xx_HAL_Driver\Inc;.\RTE\Device\STM32F407ZGTx\STCubeGenerated\Inc;.\RTE\Device\STM32F407ZGTx\STCubeGenerated\Middlewares\Third_Party\FreeRTOS\Source\inc;.\RTE\Device\STM32F407ZGTx\STCubeGenerated\Middlewares\Third_Party\FreeRTOS\Source;.\RTE\Device\STM32F407ZGTx\STCubeGenerated\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Config
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Inc/: FreeRTOSConfig.h mxconstants.h stm32f4xx_hal_conf.h stm32f4xx_it.h
    ./RTE/Device/STM32F407ZGTx/: system_stm32f4xx.c
    ./RTE/CMSIS/: RTX_Conf_CM.c
  group StartUp
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ./RTE/Device/STM32F407ZGTx/: startup_stm32f407xx.s
  group Driver
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group RTOS
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c port.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Inc/: stm32f4xx_it.h
