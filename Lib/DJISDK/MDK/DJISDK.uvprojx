# Keil uVision project DJISDK.uvprojx, settings and files
target HelloWorld (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DJISDK +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./: HelloWorld.cpp
  group Config
    ./Config/: stm32f4xx_hal_conf.h
software components: CMSIS:CORE 4.2.0, CMSIS:DSP 1.4.6, Device:STM32Cube HAL:CAN 1.4.0, Device:STM32Cube HAL:CRC 1.4.0, Device:STM32Cube HAL:Common 1.4.0, Device:STM32Cube HAL:Cortex 1.4.0, Device:STM32Cube HAL:DMA 1.4.0, Device:STM32Cube HAL:GPIO 1.4.0, Device:STM32Cube HAL:I2C 1.4.0, Device:STM32Cube HAL:RCC 1.4.0, Device:STM32Cube HAL:SRAM 1.4.0, Device:STM32Cube HAL:TIM 1.4.0, Device:STM32Cube HAL:UART 1.4.0, Device:STM32Cube HAL:USART 1.4.0, Device:STM32Cube HAL:WWDG 1.4.0, Device:Startup 2.4.0
