# Keil uVision project test.uvprojx, settings and files
target test (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: RTC +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,STM32,STM32F40x,__FPU_USED = 1,DYNAMIC_MEMORY
  c include: ..\StartUp;..\HardDrivers;..\STM32F40X_Lib\inc;..\FOSLib;..\DJISDK;..\FlightControl;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../StartUp/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group App
    ../App/: main.cpp
  group FOSLib
    ../FOSLib/: gpio.cpp littletask.cpp n1sdk.cpp servo.cpp usart.cpp wall.cpp cppforstm32.cpp
    ../App/: mechanical.cpp
  group DJISDK
    ../DJISDK/: DJI_Pro_App.cpp DJI_Pro_Codec.cpp DJI_Pro_Hw.cpp DJI_Pro_Link.cpp DJI_Pro_Test.cpp
  group FlightControl
    ../FOSLib/: flightcontrol.cpp
    ../FlightControl/: cv.cpp logic.cpp
  group HardDrivers
    ../HardDrivers/: led.c key.c rtc.c spi_flash.cpp
  group STM32F4XX_Lib
    ../STM32F40X_Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
